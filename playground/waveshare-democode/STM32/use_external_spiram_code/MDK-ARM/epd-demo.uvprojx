# Keil uVision project epd-demo.uvprojx, settings and files
target epd-demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: epd-demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;..\User\BSP;..\User\Config;..\User\e-Paper;..\User\Fonts;..\User\SDcard;..\User\Examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c user_diskio.c fatfs.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Config
    ../User/Config/: DEV_Config.c
  group BSP
    ../User/BSP/: GUI_Paint.c SPI_RAM.c
  group e-Paper
    ../User/e-Paper/: ImageData.c EPD_1in54c.c EPD_1in54.c EPD_1in54_V2.c EPD_1in54b.c EPD_2in7.c EPD_2in7b.c EPD_2in9.c EPD_2in9bc.c EPD_2in9d.c EPD_2in13.c EPD_2in13_V2.c EPD_2in13bc.c EPD_2in13d.c EPD_4in2.c EPD_4in2bc.c EPD_5in83.c EPD_5in83bc.c EPD_7in5.c EPD_7in5bc.c
  group SDcard
    ../User/SDcard/: SD_Card_APP.c SD_Card_Drive.c SD_Card_Interface.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font16.c font20.c font24.c font12CN.c font24CN.c
  group Examples
    ../User/Examples/: EPD_1in54_test.c EPD_1in54c_test.c EPD_1in54V2_test.c EPD_1in54b_test.c EPD_2in7_test.c EPD_2in7b_test.c EPD_2in9_test.c EPD_2in9bc_test.c EPD_2in9d_test.c EPD_2in13_test.c EPD_2in13V2_test.c EPD_2in13bc_test.c EPD_2in13d_test.c EPD_4in2_test.c EPD_4in2bc_test.c EPD_5in83_test.c EPD_5in83bc_test.c EPD_7in5_test.c EPD_7in5bc_test.c
software components: CMSIS:CORE 4.3.0
